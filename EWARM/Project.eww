<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\09_Nucleo-H743ZI_Ethernet.ewp</path>
  </project>
  <batchBuild />
</workspace>
